## drivers/gpu/Kconfig
```kconfig
# Added by HTC Display/Graphics for msm gpu driver

source "drivers/gpu/msm/Kconfig"
```
